Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2024-01-29T00:35:21
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jan 29 00:35:21 2024 * Host: DESKTOP-13TP49N * Database: C:\Users\andre\AppData\Local\Temp\8f60cd24-d351-4d47-92a9-e92f049f2c17\aa5b9e50-ead2-47c2-8fa0-2e9920eaa745\ifc * Database version: 5507 * Database creation date: Mon Jan 29 00:35:21 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jan 29 00:35:21 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jan 29 00:35:21 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowController: 2605AFS Oras Optima, 2605AFS(2023):2605AFS Oras Optima:145405
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - InletConnectionSize: 10 mm; NominalDepth: 148.37 mm; NominalHeight: 188.5 mm; NominalWidth: 46.4406 mm
Type - General - Author: BIMStone; BIMObjectName: 2605AFS(2023); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 17/01/2024
Type - Green Building Properties - EAN Number: 6414150103520; EN Standard: EN 817; ETIM Class Number: EC011328 Washbasin mixing tap; Sales Package dimensions (LxWxH): 380 x 180 x 74; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/2605AFS; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL REACH: http://static.oras.com/doc/reach
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/2605AFS; 3D View: https://static.oras.com/AR/2605AFS; Catalog Drawing URL: http://static.oras.com/catdrw/2605AFS; Dimension Drawing URL: http://static.oras.com/dimdrw/2605AFS; FDV Document URL: http://www.oras.com/datasheet/2605AFS/en/fdv; Group: Sales item; Installation and Maintenance Guide URL: http://static.oras.com/manual/2605AFS; Interactive AR View URL: https://static.oras.com/AR/2605AFS; Manufacturer: Oras; Market: International;Finland;Norway;Sweden;Denmark; Mobile Product Information URL: http://mpi.oras.com/2605AFS; Model: 2605AFS Oras Optima; Name_en: 2605AFS Oras Optima; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 2605AFS; Product Family: XL Single-lever;; Product Image URL: http://static.oras.com/image/2605AFS; Product URL: http://static.oras.com/2605AFS; Technical DataSheet URL: http://www.oras.com/datasheet/2605AFS/en; Type Name: 2605AFS Oras Optima; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: Inner body made of DZR brass; Aerator: PCA® - constant flow rate regardless of pressure variations; Backflow Prevention EN1717: AA; Connection: Flexible inlet pipes; Connection Size: G3/8; Excluded Items: Without pop-up waste; Installation Type: Deck mounted; Lever Handle: Single operating lever/handle;Pin shape;Hot/Cold symbols; Max. Hot Water Supply: 70 kg/K/s3; Mechanical Parts: 30Cartridge; Mounting Holes: 1 hole; Spout Projection: 114 mm; Spout Type: Fixed spout; Surface treatment: Chrome; Temperature Adjustments: Limitation option for maximum temperature and flow-rate ;Energy saving variation - cold water in the middle position; Working Pressure: 50 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 2605AFS(2023); Features: Washbasin faucet; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 2605AFS; Name: 2605AFS Oras Optima; ReplacementCost: n/a; Shape: Sculptured; Size: 50x150x190 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Offset from Host: 0 mm
Dimensions - Area: 0.0447621 m2; Volume: 0.00130681 m3
Identity Data - Mark: 59
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 2605AFS(2023): 2605AFS Oras Optima; Family and Type: 2605AFS(2023): 2605AFS Oras Optima; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 2605AFS(2023): 2605AFS Oras Optima; Type Id: 2605AFS(2023): 2605AFS Oras Optima; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
